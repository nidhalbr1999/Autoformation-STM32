# Keil uVision project led blink no hal.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: led blink no hal
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Source Group 1
    ./: main.c RCC_config.h ADC.h UART.h RCC_config.c ADC.c UART.c GPIO.c GPIO.h timer_config.c timer_config.h I2C_config.h LCD2.c LCD2.h I2C_config.c PWM.c PWM.h UltraSonic.c UltraSonic.h DHT11.c DHT11.h SPI.c SPI.h ExInterrupt.c ExInterrupt.h DMA+adc.c DMA+adc.h DMA+uart.c DMA+uart.h PowerMode.c PowerMode.h TimerInterrupt.c TimerInterrupt.h RTC.c RTC.h WDG.c WDG.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
